Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:09:28
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:09:28 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{168DE4BF-8A21-4BD1-A774-E7878900AF1B}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:09:27 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:09:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:09:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Remove Holes\IFC\C_GLE500_194_25_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Color: 0; Line Weight: 1; Symbol at End 2 Default: yes; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GLE500_194_25_3D_CAD_MULT_Prod_noholes, C_GLE500_194_25_3D_CAD_MULT_Prod_noholes:C_GLE500_194_25_3D_CAD_MULT_Prod_noholes:110067
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00399073 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE500/194/2.5
Identity Data - Description: Joist hanger; Model: GLE500/194/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Title: Wood Connectors; Model ID: 0195349791934478339734885828438984622716; ObjectType: GLE500/194/2.5; Manufacturer: Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; Product Type: Joist hanger; OmniClass Number: 23.20.40.11.24.14; URL: www.strongtie.eu; Name: GLE500/194/2.5; UniClass Number: Pr_20_29_31_44; Copyright: ©Simpson Strong-Tie
General - Reference: GLE500/194/2.5; Density: 0.88; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
